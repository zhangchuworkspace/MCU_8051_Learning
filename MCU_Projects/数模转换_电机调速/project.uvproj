# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Nixie.c Nixie.h Timer0.c Timer0.h DELAY.c DELAY.h Key.c Key.h LCD1602.h LCD1602.c
    ../定时器PWM——直流电机调速/: XPT2046.h XPT2046.c
