# Keil uVision project 示例库.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蜂鸣器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.c Timer0.h Nixie.c Nixie.h DELAY.c DELAY.h LCD1602.c LCD1602.h Key.c Key.h AT24C02.c AT24C02.h DS18B20.c DS18B20.h I2C.c I2C.h OneWire.c OneWire.h
