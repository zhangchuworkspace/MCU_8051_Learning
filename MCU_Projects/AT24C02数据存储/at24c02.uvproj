# Keil uVision project at24c02.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: at24c02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Key.h LCD1602.c LCD1602.h DELAY.c DELAY.h Key.c I2C.c I2C.h AT24C02.c AT24C02.h
